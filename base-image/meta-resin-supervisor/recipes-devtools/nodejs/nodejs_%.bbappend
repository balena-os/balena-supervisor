GYP_DEFINES_append = " v8_target_arch='x87' "
